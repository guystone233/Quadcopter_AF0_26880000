# Keil uVision project AF0Fly.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AF0Fly +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F401xx, USE_STDPERIPH_DRIVER, ARM_MATH_CM4,MPL_LOG_NDEBUG=1,MPU6050,EMPL,USE_DMP,EMPL_TARGET_STM32F4
  c include: ..\User;..\Lib\inc;..\Hardware;..\Ucosii\Source;..\Ucosii\Cfg\Template;..\Ucosii\Ports;..\Ucosii\Trace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ../User/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h main.c tasks.c tasks.h ano.c ano.h ekf.c ekf.h
  group Startup
    ../Startup/: startup_stm32f401xx.s
  group Lib_Inc
    ../Lib/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group Lib_Src
    ../Lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Hardware
    ../Hardware/: led.c led.h oled.c oled.h oled_font.h tim.c tim.h usart.h usart.c gy86.c gy86.h i2c.c i2c.h myexti.c myexti.h
  group Ucosii
    ../Ucosii/Cfg/Template/: app_cfg.h app_hooks.c os_cfg.h
    ../Ucosii/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ../Ucosii/Source/: os.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.h
    ../Ucosii/Trace/: os_trace_events.c os_trace_events.h
  group DMP
    ../DMP/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h accel_auto_cal.h compass_vec_cal.h data_builder.c data_builder.h eMPL_outputs.c eMPL_outputs.h fast_no_motion.h fusion_9axis.h gyro_tc.h hal_outputs.c hal_outputs.h heading_from_gyro.h inv_math.h invensense.h invensense_adv.h libmpllib.lib log.h log_stm32.c mag_disturb.h message_layer.c message_layer.h ml_math_func.c ml_math_func.h mlinclude.h mlmath.c mlmath.h mlos.h mltypes.h motion_no_motion.h mpl.c mpl.h mpu6050.c mpu6050.h no_gyro_fusion.h packet.h quaternion_supervisor.h results_holder.c results_holder.h start_manager.c start_manager.h stdint_invensense.h mpu.h storage_manager.c storage_manager.h delay.c delay.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.4, CMSIS:DSP:Compute Graph 1.14.4
