# Keil uVision project ucos2.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ucos2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\ucosii\Cfg\Template;.\ucosii\Source;.\app;.\ucosii\Ports;.\hardware
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group hardware
    ./hardware/: led.c led.h
  group app
    ./app/: main.c
  group ucosii
    ./ucosii/Source/: os.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.h
    ./ucosii/Cfg/Template/: app_cfg.h app_hooks.c os_cfg.h
    ./ucosii/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
